## avogadro generated ORCA input file 
# Advanced Mode
# Single point energy calculation
! B3LYP SP aug-cc-pVTZ TightSCF 
%scf
	MaxIter 125
	CNVDIIS 1
	CNVSOSCF 1 
end
* xyz 0 1
  He        0.36850        1.29050        0.00000
*

